# Keil uVision project gd32f303_test.uvprojx, settings and files
target Target 1 (6230000::V6.23::ARMCLANG)
  device: GD32F303CB GigaDevice
  pack: GigaDevice.GD32F30x_DFP.2.2.1
  cpu: IRAM(0x20000000,0x08000) IROM(0x08000000,0x020000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: gd32f303_test
  c flags: OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: GD32F303
  c include: ..\User;..\Firmware\CMSIS\GD\GD32F30x\Include;..\Firmware\CMSIS;..\Firmware\GD32F30x_standard_peripheral\Include;..\Hardware
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group User
    ../User/: gd32f30x_it.c main.c systick.c
  group Firmware
    ../Firmware/GD32F30x_standard_peripheral/Source/: gd32f30x_adc.c gd32f30x_bkp.c gd32f30x_can.c gd32f30x_crc.c gd32f30x_ctc.c gd32f30x_dac.c gd32f30x_dbg.c gd32f30x_dma.c gd32f30x_enet.c gd32f30x_exmc.c gd32f30x_exti.c gd32f30x_fmc.c gd32f30x_fwdgt.c gd32f30x_gpio.c gd32f30x_i2c.c gd32f30x_misc.c gd32f30x_pmu.c gd32f30x_rcu.c gd32f30x_rtc.c gd32f30x_sdio.c gd32f30x_spi.c gd32f30x_timer.c gd32f30x_usart.c gd32f30x_wwdgt.c
  group CMSIS
    ../Firmware/CMSIS/GD/GD32F30x/Source/: system_gd32f30x.c
    ../Firmware/CMSIS/GD/GD32F30x/Source/ARM/: startup_gd32f30x_xd.s
  group Hardware
    ../Hardware/: uart.c spi.c iic.c timer.c platform.c
software components: CMSIS:CORE 6.1.0
